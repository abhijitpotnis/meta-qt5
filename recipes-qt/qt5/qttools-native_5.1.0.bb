require qt5-${PV}.inc
require ${PN}.inc

SRC_URI[md5sum] = "e0fcf75d1e90454bc8a6c576a3a256e6"
SRC_URI[sha256sum] = "e2841839b960c3fdf8bbc9dc7bbf3792b3fc3e86cd726be864d9152fb006e9a0"
